# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  c include: ..\..\F103_Library;..\..\Hardware_Library
  asm include: .\F103_Library
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
    ../../F103_Library/: delay.c gpio.c spi.c Timer.c delay.h gpio.h spi.h Timer.h gp_drive.c gp_drive.h i2c_drive.c i2c_drive.h systick_time.c systick_time.h
    ../../Hardware_Library/: MAX7219.c MAX7219.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
